## Kconfig
```kconfig
menu "TractorKit Commander OS Settings"
    menu "Platform"

    endmenu
    menu "GPIO (except display)"
        
    endmenu
endmenu
```
